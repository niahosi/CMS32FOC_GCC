# Keil uVision project CMS32M65xx_FOC.uvprojx, settings and files
target CMS32M65xx_FOC_V3 (5060960::V5.06 update 7 (build 960)::.\ARMComplier506)
  device: CMS32M6510GE24SS Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMS32M65xx_FOC +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Driver\inc;..\..\Device\Include;..\code\2_mcu_h;..\code\3_algorithm_h;..\code\4_ctrl_h;..\code\5_user_h;..\code;..\..\SEGGER_RTT
  memory RVCT4: ROM 0x0 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group 6_SETPARA
    ../code/5_user_h/: Set_HW.h Set_FOC.h Set_SPEED.h Set_MODE.h Set_PROTECT.h
  group 5_user_s
    ../code/5_user_s/: main.c interrupt.c user_Ctrl.c user_Function.c measure.c
  group 4_ctrl_s
    ../code/4_ctrl_s/: MC_Ctrl.c MC_Wind.c MC_Fault.c MC_PID.c MC_FOC.c MC_SoftInit.c MC_TriangleFun.c MC_FOC_Fun.c
  group 3_algorithm_s
    ../code/3_algorithm_s/: CMS65_FOCA303_L2_A02 _20260420.lib
  group 2_mcu_s
    ../code/2_mcu_s/: mcu_port.c mcu_init.c isr.c
  group 1.5_RTT
    ../../SEGGER_RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group 1_driver_s
    ../../Driver/src/: acmp.c adc.c adcldo.c ccp.c cgc.c dac.c delay.c divsqrt.c epwm.c flash.c gpio.c pga.c timer.c timer4.c uart.c wdt.c i2c.c lsitimer.c ssp.c
  group 1_driver_h
    ../../Driver/inc/: acmp.h adc.h adcldo.h ccp.h cgc.h common.h dac.h delay.h divsqrt.h epwm.h flash.h gpio.h i2c.h lsitimer.h pga.h ssp.h timer.h timer4.h uart.h wdt.h
  group 0_device
    ../../Device/Source/: system_CMS32M6510.c
    ../../Device/Source/ARM/: startup_CMS32M6510.s
  group record
    ../code/: Record.txt
