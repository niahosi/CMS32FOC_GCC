# Keil uVision project CMS32FOCAC6.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMComplier506)
  device: CMS32M6510GE24SS Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMS32FOCAC6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\User\App\Inc;.\User\Board\Inc;.\User\Motor\Inc;.\User\Config;.\Vendor\Cmsemicon\CMS32M65xx\CMSIS\Include;.\Vendor\Cmsemicon\CMS32M65xx\Device\Include;.\Vendor\Cmsemicon\CMS32M65xx\Driver\inc;.\Vendor\SeggerRtt
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ./User/App/Src/: main.c App_Debug.c
  group Board
    ./User/Board/Src/: Board.c Board_Analog.c Board_MA600.c Board_PWM.c
  group Config
    ./User/Config/: Config.h
  group Motor
    ./User/Motor/Src/: Motor.c Motor_Foc.c Motor_Loop.c Motor_OpenLoop.c Motor_ZeroScanTest.c
  group Vendor_Device
    ./Vendor/Cmsemicon/CMS32M65xx/Device/Source/: system_CMS32M6510.c
  group Vendor_Driver
    ./Vendor/Cmsemicon/CMS32M65xx/Driver/src/: cgc.c delay.c gpio.c ssp.c adc.c adcldo.c pga.c epwm.c
  group Vendor_Startup
    ./Vendor/Cmsemicon/CMS32M65xx/Device/Source/ARM/: startup_CMS32M6510.s
  group Vendor_Rtt
    ./Vendor/SeggerRtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
