# Keil uVision project time4IntervalTimer.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M6510GE24SS Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\app_code\include;..\..\..\..\..\Driver\include;..\..\..\..\..\Device\Include;..\..\..\..\..\Driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: main.c
  group App
    ../../app_code/src/: retarget.c demo_uart.c demo_timer4.c demo_delay.c
  group Bsp
    ../../../../../Driver/src/: gpio.c timer4.c uart.c delay.c cgc.c
    ./: isr.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
