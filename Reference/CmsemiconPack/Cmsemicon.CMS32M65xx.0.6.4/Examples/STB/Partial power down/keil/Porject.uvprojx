# Keil uVision project Porject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M6510GE16SP Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Porject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code;..\..\..\..\Device\Include;..\..\..\..\CMSIS\Include;..\..\..\..\Driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ../code/: main.c
  group App
    ../code/: isr.c demo_extint.c
  group Driver
    ../../../../Driver/src/: cgc.c gpio.c uart.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
