# Keil uVision project Blinky.uvprojx, settings and files
target CMS32M6510 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M6510GE16SP Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c include: ..\..\..\CMSIS\Include;..\..\..\Device\CMS32X506\Include;..\..\..\Driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ../: main.c
  group Bsp
    ../../../Driver/src/: gpio.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
