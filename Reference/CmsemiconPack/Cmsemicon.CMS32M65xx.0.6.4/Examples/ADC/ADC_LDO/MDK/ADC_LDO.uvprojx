# Keil uVision project ADC_LDO.uvprojx, settings and files
target CMS32M6510 (5060960::V5.06 update 7 (build 960)::.\ARMComplier506)
  device: CMS32M6510GE24SS Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\CMSIS\Include;..\..\..\Driver\inc;..\APP;..\..\..\..\Driver\inc;..\..\..\..\Device\CMS32X506\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ../: main.c
  group App
    ../APP/: retarget.c demo_adc.c isr.c demo_uart.c demo_adcldo.c
  group Driver
    ../../../../Driver/src/: gpio.c uart.c cgc.c adc.c adcldo.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
