# Keil uVision project SPI_Master_95256.uvprojx, settings and files
target CMS32M6510 (6240000::V6.24::ARMCLANG)
  device: CMS32M6510GE24SS Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\CMSIS\Include;..\..\..\Driver\inc;..\APP;..\..\..\..\Driver\inc;..\..\..\..\Device\CMS32X506\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ../: main.c
  group App
    ../APP/: demo_uart.c isr.c retarget.c demo_spi.c
  group Driver
    ../../../../Driver/src/: gpio.c uart.c cgc.c ssp.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
