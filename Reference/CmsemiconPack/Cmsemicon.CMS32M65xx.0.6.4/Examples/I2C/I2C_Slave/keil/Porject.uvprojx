# Keil uVision project Porject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M6510GE16SP Cmsemicon
  pack: Cmsemicon.CMS32M65xx.0.6.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Porject
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code;..\..\..\..\CMSIS\Include;..\..\..\..\Driver\inc;..\..\..\..\Device\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ../code/: main.c
  group Driver
    ../../../../Driver/src/: gpio.c cgc.c i2c.c uart.c
  group App
    ../code/: demo_i2c.c isr.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
